# Keil uVision project uvprj.uvprojx, settings and files
target STM32F0 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: uvprj +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030
  c include: .\STLib\CMSIS\Include;.\STLib\CMSIS\Device\Include;.\STLib\STM32F0xx_StdPeriph_Driver\inc;.\Source;..\frame
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Header
    ./Source/: stm32f0xx_conf.h Driver.h
    ./source/: Cfg.h
    ../frame/: CaFrame.h
  group Source
    ./Source/: App.c
  group CAFrame
    ./Source/: Driver.c
    ../frame/: Frame.c
  group STLib
    ./STLib/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_misc.c stm32f0xx_usart.c
  group CMSIS
    ./STLib/CMSIS/Device/Source/arm/: startup_stm32f030.s
    ./STLib/CMSIS/Device/Source/: system_stm32f0xx.c
