# Keil uVision project STM32G0.uvprojx, settings and files
target STM32G0 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32G030F6Px STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x8007FFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: STM32G0 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,STM32G030xx,BOOT_APP
  c include: ../User/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;..\..\..\frame
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group MDK-ARM
    ./: startup_stm32g030xx.s
  group Application
    ../User/Src/: app.c veep.c
  group LL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_ll_utils.c stm32g0xx_ll_gpio.c stm32g0xx_ll_dma.c stm32g0xx_ll_rcc.c stm32g0xx_ll_pwr.c stm32g0xx_ll_usart.c stm32g0xx_ll_tim.c stm32g0xx_ll_adc.c
  group CMSIS
    ../User/Src/: system_stm32g0xx.c
  group Header
    ../User/Inc/: stm32g0xx_it.h app.h veep.h flash.h
  group BORD_Driver
    ../User/Inc/: driver.h
    ../User/Src/: stm32g0xx_it.c driver.c flash.c
  group CAFrame
    ../../../frame/: Frame.c CaFrame.h
    ../User/Inc/: Cfg.h
software components: CMSIS:CORE 4.3.0
