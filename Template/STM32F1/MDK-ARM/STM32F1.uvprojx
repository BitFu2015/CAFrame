# Keil uVision project STM32F1.uvprojx, settings and files
target STM32F1 (6180000::V6.18::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F1 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_FULL_LL_DRIVER,STM32F103xB,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,HSI_VALUE=8000000,LSI_VALUE=40000,VDD_VALUE=3300,PREFETCH_ENABLE=1
  c misc: -Wno-invalid-source-encoding
  c include: ..\User;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\..\..\Frame
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Src
    ../User/: stm32f1xx_it.c 24cxx.c App.c Driver.c serial.c 24cxx.h App.h Driver.h serial.h
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_ll_gpio.c stm32f1xx_ll_adc.c stm32f1xx_ll_dma.c stm32f1xx_ll_rcc.c stm32f1xx_ll_utils.c stm32f1xx_ll_exti.c stm32f1xx_ll_pwr.c stm32f1xx_ll_usart.c stm32f1xx_ll_tim.c
  group Drivers/CMSIS
    ../User/: system_stm32f1xx.c
  group CAFrame
    ../../../frame/: Frame.c
    ../../../Frame/: CaFrame.h
    ../User/: Cfg.h
  group Header
    ../User/: 24cxx.h App.h Cfg.h Driver.h serial.h
software components: CMSIS:CORE 5.6.0
