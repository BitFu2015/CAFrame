# Keil uVision project STM32F0.uvprojx, settings and files
target STM32F0 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0") TZ
  output: STM32F0 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,HSI_VALUE=8000000,LSI_VALUE=40000,VDD_VALUE=3300,PREFETCH_ENABLE=1,INSTRUCTION_CACHE_ENABLE=0,DATA_CACHE_ENABLE=0,STM32F030x6
  c include: ../Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include;..\..\..\frame
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Application/MDK-ARM
    ../Src/: stm32f0xx_it.c
    ./: startup_stm32f030x6.s
  group Application/User
    ../Src/: App.c Driver.c eep.c iic.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_gpio.c stm32f0xx_ll_adc.c stm32f0xx_ll_rcc.c stm32f0xx_ll_utils.c stm32f0xx_ll_exti.c stm32f0xx_ll_pwr.c stm32f0xx_ll_usart.c stm32f0xx_ll_tim.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Header
    ../Inc/: Driver.h eep.h iic.h
  group CAFrame
    ../Inc/: Cfg.h
    ../../../frame/: CaFrame.h Frame.c
software components: CMSIS:CORE 4.3.0
