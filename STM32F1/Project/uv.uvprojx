# Keil uVision project uv.uvprojx, settings and files
target STM32Frame (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MBIO +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c misc: --c99
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Project;..\app;..\drv;..\..\frame
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0xd000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Driver
    ../drv/: Driver.c serial.c queue.c 24cxx.c Timer.c adc.c
  group App
    ../app/: App.c
  group Header
    ../drv/: stm32f10x_conf.h Driver.h serial.h queue.h 24cxx.h adc.h
    ../App/: Cfg.h
    ../../Frame/: CaFrame.h
  group STM32Lib
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_iwdg.c stm32f10x_dac.c stm32f10x_dma.c
  group MDK-ARM
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../drv/: system_stm32f10x.c
  group Doc
    ../: ReadMe.txt
  group CAFrame
    ../../Frame/: Frame.c
